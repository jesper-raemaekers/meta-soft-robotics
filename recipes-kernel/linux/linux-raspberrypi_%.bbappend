FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://i2c.cfg"
SRC_URI += "file://01-i2c.patch"
