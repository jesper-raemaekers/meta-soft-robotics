SRC_URI:append = "file://fragment.cfg"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"